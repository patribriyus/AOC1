# Keil uVision project practica2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: practica2
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: .\practica1.sct
  group Source Group 1
    ./: mensaje.s p2.s p2_bueno.s
